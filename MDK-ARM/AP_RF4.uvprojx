# Keil uVision project AP_RF4.uvprojx, settings and files
target AP_RF4 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AP_RF4 +hex
  AfterMake: C:/Keil_v5/ARM/ARMCC/bin/fromelf.exe --bin -o ./AP_RF4/AP_RF4.bin ./AP_RF4/AP_RF4.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;           ../Drivers/STM32F4xx_HAL_Driver/Inc;           ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;           ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;           ../Drivers/CMSIS/Include;           ..\User\ToN1_uart;           ..\User\GPRS;           ..\User;           ..\User\RF4;           ..\User\Debug_uart;           ..\User\Ap_param;           ..\User\rf_data_handle
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
  group Debug_uart
    ../User/Debug_uart/: debug_uart.c
    ../Src/: debug.c
  group AP-N1_uart
    ../User/ToN1_uart/: from_n1.c to_n1.c
    ../Src/: from_n1_store_s_rp_frimware.c
  group Gprs_uart
    ../User/GPRS/: gprs_hal.c gprs_comm.c gprs_4g_app.c
  group Rf_4_spi
    ../User/RF4/: rf_hal.c rf.c
    ../Src/: update_s_rp.c
  group Storage
    ../User/Ap_param/: ap_param.c eeprom.c
    ../Src/: flash.c
  group New Group
    ../User/rf_data_handle/: rf_data_handle.c timer_and_realtime_data.c
software components: CMSIS:CORE 5.0.1
